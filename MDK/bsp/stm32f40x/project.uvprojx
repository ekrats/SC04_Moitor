# Keil uVision project project.uvprojx, settings and files
target rt-thread_stm32f4xx (5060183::V5.06 update 2 (build 183)::ARMCC)
  device: STM32F407ZGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.4.0
  cpu: IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) IROM(0x08000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: RT_OS_SC +hex
  AfterMake: fromelf --bin !L --output rtthread.bin
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c define: USE_STDPERIPH_DRIVER
  c include: .;..\..\components\finsh;..\..\include;..\..\libcpu\arm\common;..\..\libcpu\arm\cortex-m4;Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x;Libraries\CMSIS\Include;Libraries\CMSIS\ST\STM32F4xx\Include;Libraries\STM32F4xx_StdPeriph_Driver\inc;applications;drivers;.\HardwareInit;.\can;.\UserLib;..\..\components\net\freemodbus-v1.6.0\port;..\..\components\net\freemodbus-v1.6.0\modbus\rtu;..\..\components\net\freemodbus-v1.6.0\modbus\include;.\rs485;.\pcmaster;.\AdIo;.\Record;.\UserApp;.\flash;..\..\components\drivers\include
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  link misc: --keep __fsym_* --keep __vsym_*
  group Applications
    applications/: application.c startup.c
  group UserApp
    ./UserApp/: logicTask.cc thread_x_run.cc logicApp.cc app_Fault.cc appModule.cc appMonitor.cc sysInfo.cc
  group Can
    ./can/: canTask.cc canApp.cc canLinker.cc Bsp_can.c canRxQueue.cc canTxQueue.cc
  group AdIo
    ./AdIo/: AdIo_task.cc adApp.cc Bsp_ad.c Bsp_io.c
  group HardwareInit
    ./HardwareInit/: Bsp_Board_Init.c
  group UserLib
    ./UserLib/: config.c crc16.c pt100.c Bsp_bakram.c Bsp_rtc.c rtc.c
  group Drivers
    drivers/: board.c serial.c stm32f4xx_it.c usart.c
    ./drivers/: Bsp_systimer.c cpuusage.c hardware_crc32.c
    ../../components/drivers/spi/: spi_core.c spi_dev.c
  group Kernel
    ../../src/: clock.c device.c idle.c ipc.c irq.c kservice.c mem.c mempool.c object.c scheduler.c thread.c timer.c
  group finsh
    ../../components/finsh/: cmd.c finsh_compiler.c finsh_error.c finsh_heap.c finsh_init.c finsh_node.c finsh_ops.c finsh_parser.c finsh_token.c finsh_var.c finsh_vm.c shell.c symbol.c
  group CORTEX-M4
    ../../libcpu/arm/cortex-m4/: cpuport.c context_rvds.S
    ../../libcpu/arm/common/: backtrace.c div0.c showmem.c
  group STM32_StdPeriph
    Libraries/CMSIS/ST/STM32F4xx/Source/Templates/: system_stm32f4xx.c
    Libraries/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dma.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_pwr.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sdio.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
    Libraries/CMSIS/ST/STM32F4xx/Source/Templates/arm/: startup_stm32f4xx.s
  group FreeModbus
    ../../components/net/freemodbus-v1.6.0/port/: Bsp_mb_task.c user_mb_app.c port.c
    ../../components/net/freemodbus-v1.6.0/modbus/functions/: mbfuncother.c
    ../../components/net/freemodbus-v1.6.0/modbus/rtu/: mbcrc.c
  group FreeModbusSlave
    ../../components/net/freemodbus-v1.6.0/modbus/: mb.c
    ../../components/net/freemodbus-v1.6.0/modbus/functions/: mbfunccoils.c mbfuncdisc.c mbfuncholding.c mbfuncinput.c mbutils.c
    ../../components/net/freemodbus-v1.6.0/modbus/rtu/: mbrtu.c
    ../../components/net/freemodbus-v1.6.0/port/: portevent.c portserial.c porttimer.c
  group FreeModbusMaster
    ../../components/net/freemodbus-v1.6.0/modbus/: mb_m.c
    ../../components/net/freemodbus-v1.6.0/modbus/functions/: mbfunccoils_m.c mbfuncdisc_m.c mbfuncholding_m.c mbfuncinput_m.c
    ../../components/net/freemodbus-v1.6.0/modbus/rtu/: mbrtu_m.c
    ../../components/net/freemodbus-v1.6.0/port/: portevent_m.c portserial_m.c porttimer_m.c
  group pcmaster
    ./pcmaster/: multi_serial.c pcmaster.c
  group flash
    ./flash/: flash_storage_at45dbxx.c spi_flash_at45dbxx.c stm32f20x_40x_spi.c spi_flash.c
software components: CMSIS:CORE 4.3.0
